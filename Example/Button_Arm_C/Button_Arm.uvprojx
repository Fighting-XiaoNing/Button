# Keil uVision project Button_Arm.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Button_Arm +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: .\Chip\Core;.\Chip\Library\Inc;.\User\APL;.\User\BLL;.\User\FML;.\User\OSL;.\User\HDL;.\User\HAL
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Chip/Core
    ./Chip/Core/: startup_stm32f10x_hd.s stm32f1xx_hal_msp.c stm32f1xx_it.c system_stm32f1xx.c
  group Chip/Library
    ./Chip/Library/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c
  group User/APL
    ./User/APL/: main.c
  group User/FML
    ./User/FML/: FmlButton.c
  group User/HDL
    ./User/HDL/: HdlButton.c
software components: CMSIS:CORE 5.6.0
